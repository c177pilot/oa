<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ahrs_gps_eis_to_fg</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>openavionics_gns430_to_fg</key>
<param><key>id</key><value>openavionics_gns430_to_fg_0</value></param>
<param><key>ip_addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>5502</value></param>
</block>
<block>
<key>openavionics_gns430_parser</key>
<param><key>id</key><value>openavionics_gns430_parser_0</value></param>
</block>
<block>
<key>openavionics_eis_parser</key>
<param><key>id</key><value>openavionics_eis_parser_0</value></param>
</block>
<block>
<key>openavionics_ahrs_parser</key>
<param><key>id</key><value>openavionics_ahrs_parser_0</value></param>
</block>
<block>
<key>openavionics_serial_io</key>
<param><key>id</key><value>openavionics_serial_io_0</value></param>
<param><key>device</key><value>/dev/pts/10</value></param>
<param><key>stopbits</key><value>0</value></param>
<param><key>parity</key><value>0</value></param>
<param><key>bytesize</key><value>1</value></param>
<param><key>waitfornewline</key><value>False</value></param>
<param><key>baudrate</key><value>19200</value></param>
</block>
<block>
<key>openavionics_serial_io</key>
<param><key>id</key><value>openavionics_serial_io_0_0</value></param>
<param><key>device</key><value>/dev/pts/12</value></param>
<param><key>stopbits</key><value>0</value></param>
<param><key>parity</key><value>0</value></param>
<param><key>bytesize</key><value>1</value></param>
<param><key>waitfornewline</key><value>False</value></param>
<param><key>baudrate</key><value>19200</value></param>
</block>
<block>
<key>openavionics_serial_io</key>
<param><key>id</key><value>openavionics_serial_io_0_0_0</value></param>
<param><key>device</key><value>/dev/pts/14</value></param>
<param><key>stopbits</key><value>0</value></param>
<param><key>parity</key><value>0</value></param>
<param><key>bytesize</key><value>1</value></param>
<param><key>waitfornewline</key><value>False</value></param>
<param><key>baudrate</key><value>19200</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>openavionics_ahrs_to_fg</key>
<param><key>id</key><value>openavionics_ahrs_to_fg_0</value></param>
<param><key>ip_addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>5501</value></param>
</block>
<connection><source_block_id>openavionics_serial_io_0_0_0</source_block_id><sink_block_id>openavionics_gns430_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>openavionics_gns430_parser_0</source_block_id><sink_block_id>openavionics_gns430_to_fg_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>openavionics_ahrs_parser_0</source_block_id><sink_block_id>openavionics_ahrs_to_fg_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>openavionics_serial_io_0</source_block_id><sink_block_id>openavionics_ahrs_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>openavionics_serial_io_0_0</source_block_id><sink_block_id>openavionics_eis_parser_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>openavionics_gns430_parser_0</source_block_id><sink_block_id>blocks_message_debug_0_0_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>openavionics_eis_parser_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>openavionics_ahrs_parser_0</source_block_id><sink_block_id>blocks_message_debug_0_0_1</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
</flow_graph>
