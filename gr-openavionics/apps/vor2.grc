<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>vor2</value></param>
<param><key>title</key><value>VOR Receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-10</value></param>
<param><key>max</key><value>10</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>10**(volume/10)</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_0</value></param>
<param><key>rate</key><value>channel_rate</value></param>
<param><key>len</key><value>dir_scale*audio_scale</value></param>
<param><key>freq</key><value>30</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0, channel_rate, 500, 100, firdes.WIN_HAMMING)</value></param>
<param><key>center_freq</key><value>fm_subcarrier</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>delay</key><value>int(channel_rate/30*0.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>10000</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_scale</value></param>
<param><key>value</key><value>int(rf_rate/channel_rate) + rf_rate % channel_rate</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>channel</value></param>
<param><key>label</key><value>Channel (Hz)</value></param>
<param><key>value</key><value>113.9e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>offset</value></param>
<param><key>value</key><value>fm_subcarrier + 4000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fm_subcarrier</value></param>
<param><key>value</key><value>9960</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rf_rate</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_rate</value></param>
<param><key>value</key><value>40000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dir_rate</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>dir_scale</value></param>
<param><key>value</key><value>int(audio_rate/dir_rate) + audio_rate % dir_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_scale</value></param>
<param><key>value</key><value>int(channel_rate/audio_rate) + channel_rate % audio_rate</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>m</key><value>120</value></param>
<param><key>n</key><value>120</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>AM audio</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>dir_rate</value></param>
<param><key>cutoff_freq</key><value>1</value></param>
<param><key>width</key><value>2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>zeroer</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>zero_point*(math.pi/180)</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Direction</value></param>
<param><key>units</key><value>deg</value></param>
<param><key>samp_rate</key><value>dir_rate</value></param>
<param><key>min_value</key><value>-180</value></param>
<param><key>max_value</key><value>180</value></param>
<param><key>factor</key><value>180/math.acos(-1)</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>dir_rate</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>.25</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>zero_point</value></param>
<param><key>label</key><value>Zero adjust (degrees)</value></param>
<param><key>value</key><value>-5</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>AM Signal</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>baseband_freq</key><value>channel</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>128</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_1_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FM Signal</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>30Hz Signals</value></param>
<param><key>samp_rate</key><value>dir_rate</value></param>
<param><key>v_scale</key><value>2</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>30</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>win_size</key><value>500, 500</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value></value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>low_cutoff_freq</key><value>20</value></param>
<param><key>high_cutoff_freq</key><value>40</value></param>
<param><key>width</key><value>20</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>audio_scale</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>low_cutoff_freq</key><value>20</value></param>
<param><key>high_cutoff_freq</key><value>40</value></param>
<param><key>width</key><value>20</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>float</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Channel</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>baseband_freq</key><value>channel</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.25</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>RF Data</value></param>
<param><key>samp_rate</key><value>rf_rate</value></param>
<param><key>baseband_freq</key><value>channel-offset</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>10</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>vor_freq</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>113.9e6</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>channel_rate</value></param>
<param><key>cutoff_freq</key><value>10000</value></param>
<param><key>width</key><value>4000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0</value></param>
<param><key>rate</key><value>audio_rate</value></param>
<param><key>len</key><value>dir_scale</value></param>
<param><key>freq</key><value>30</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>chan_rate</key><value>40e3</value></param>
<param><key>audio_decim</key><value>4</value></param>
<param><key>audio_pass</key><value>5000</value></param>
<param><key>audio_stop</key><value>5500</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>type</key><value>ff</value></param>
<param><key>length</key><value>128</value></param>
<param><key>long_form</key><value>True</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>rf_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(vor_freq,20e6)</value></param>
<param><key>gain0</key><value>20</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>40</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/home/john/apps/aviation_rx/woodside_vor25.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>1e6</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>65536</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>rf_scale</value></param>
<param><key>taps</key><value>firdes.low_pass(1.0, rf_rate, channel_rate, channel_rate/2, firdes.WIN_HAMMING)</value></param>
<param><key>center_freq</key><value>900</value></param>
<param><key>samp_rate</key><value>rf_rate</value></param>
</block>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>wxgui_fftsink2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>goertzel_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0</source_block_id><sink_block_id>analog_agc2_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>zeroer</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeroer</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_1</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_1_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>goertzel_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>analog_agc2_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_1</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
