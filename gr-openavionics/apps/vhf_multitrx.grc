<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>max_nouts</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>band_center_freq</value></param>
<param><key>value</key><value>(136.975e6-108.0e6)/2+108.0e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vor_center_freq</value></param>
<param><key>value</key><value>(117.95e6-108.00e6)/2+117.95e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>phase_correction</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vor_samp_rate</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>am_sample_rate</value></param>
<param><key>value</key><value>12.5e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vor_center_freq_0</value></param>
<param><key>value</key><value>(117.95e6-108.00e6)/2+117.95e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>am_decimation</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_sample_rate</value></param>
<param><key>value</key><value>48e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rxgain</value></param>
<param><key>value</key><value>15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>obs_sample_rate</value></param>
<param><key>value</key><value>am_sample_rate/obs_decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>obs_decimation</value></param>
<param><key>value</key><value>25</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ils_sample_rate</value></param>
<param><key>value</key><value>am_sample_rate/ils_decimation</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ils_decimation</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>antenna</value></param>
<param><key>value</key><value>TX/RX</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>notebook_0</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['RF Analyzer', 'Channel FFT', 'Demod Audio FFT', 'Ref and Phase Scope','Manipulated Ref and Phase']</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0_0</value></param>
<param><key>stream_id</key><value>com</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>nav</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>am_demod_cf_0</value></param>
<param><key>chan_rate</key><value>am_sample_rate</value></param>
<param><key>audio_decim</key><value>am_decimation</value></param>
<param><key>audio_pass</key><value>3e3</value></param>
<param><key>audio_stop</key><value>4e3</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>vor_freq_entry_2</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>vor_freq_2</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vor_freq_1</value></param>
<param><key>value</key><value>111e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>com_freq_1</value></param>
<param><key>value</key><value>135.275e6</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>com_freq_entry_1</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>com_freq_1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>vor_freq_2</value></param>
<param><key>value</key><value>111e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>null_sink_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>audio_select</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0, 1]</value></param>
<param><key>labels</key><value>['AM Voice','VOR Subcarrier']</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.450</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>multiply_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>multiply_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>add_xx_0_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>float_to_complex_0_0</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>const_source_x_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0.550</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>const_source_x_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>0.450</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_1</value></param>
<param><key>type</key><value>interp_fir_filter_fff</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>12.5e3</value></param>
<param><key>cutoff_freq</key><value>3e3</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>FFT Plot</value></param>
<param><key>samp_rate</key><value>12.5e3</value></param>
<param><key>baseband_freq</key><value>0</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>fft_rate</key><value>5</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>480</value></param>
<param><key>decim</key><value>125</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>int(audio_sample_rate)</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:0 A:0</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>vor_samp_rate</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(com_freq_entry_1,rf_freq=band_center_freq, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain0</key><value>gain_slider</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>uhd.tune_request(vor_freq_entry_1, rf_freq=band_center_freq, rf_freq_policy=uhd.tune_request.POLICY_MANUAL)</value></param>
<param><key>gain1</key><value>gain_slider</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>10e3</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>notebook</key><value>notebook_0,1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>4</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>40e3</value></param>
<param><key>low_cutoff_freq</key><value>20</value></param>
<param><key>high_cutoff_freq</key><value>40</value></param>
<param><key>width</key><value>20</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_3</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>10e3</value></param>
<param><key>cutoff_freq</key><value>1</value></param>
<param><key>width</key><value>2</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0_0</value></param>
<param><key>rate</key><value>10000</value></param>
<param><key>len</key><value>1000</value></param>
<param><key>freq</key><value>30</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>10e3</value></param>
<param><key>low_cutoff_freq</key><value>20</value></param>
<param><key>high_cutoff_freq</key><value>40</value></param>
<param><key>width</key><value>20</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_1_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>analog_agc2_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1e-1</value></param>
<param><key>decay_rate</key><value>1e-2</value></param>
<param><key>reference</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>100</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>analog_am_demod_cf_0</value></param>
<param><key>chan_rate</key><value>40e3</value></param>
<param><key>audio_decim</key><value>4</value></param>
<param><key>audio_pass</key><value>5000</value></param>
<param><key>audio_stop</key><value>5500</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>units</key><value>Units</value></param>
<param><key>samp_rate</key><value>10</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>show_gauge</key><value>True</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>-87.2665e-3</value></param>
</block>
<block>
<key>blocks_complex_to_arg</key>
<param><key>id</key><value>blocks_complex_to_arg_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>goertzel_fc</key>
<param><key>id</key><value>goertzel_fc_0</value></param>
<param><key>rate</key><value>40000</value></param>
<param><key>len</key><value>4000</value></param>
<param><key>freq</key><value>30</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>40e3</value></param>
<param><key>cutoff_freq</key><value>2e3</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>40e3</value></param>
<param><key>cutoff_freq</key><value>2e3</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>interp</key><value>4</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>taps</key><value></value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>40e3</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
<param><key>freq</key><value>-9.96e3</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>null_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_2</value></param>
<param><key>type</key><value>fff</value></param>
<param><key>interp</key><value>250</value></param>
<param><key>decim</key><value>48</value></param>
</block>
<block>
<key>openavionics_joystick_interface</key>
<param><key>id</key><value>openavionics_joystick_interface_0</value></param>
</block>
<block>
<key>openavionics_audio_ptt</key>
<param><key>id</key><value>openavionics_audio_ptt_0</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>vor_freq_entry_1</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>vor_freq_1</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch_slider</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>-110</value></param>
<param><key>min</key><value>-110</value></param>
<param><key>max</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain_slider</value></param>
<param><key>label</key><value></value></param>
<param><key>value</key><value>gain</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>30</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>notebook</key><value>notebook_0,0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>int(250e3/12.5e3)</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>vor_samp_rate</value></param>
<param><key>cutoff_freq</key><value>10e3</value></param>
<param><key>width</key><value>1e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_agc2_xx</key>
<param><key>id</key><value>agc2_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>attack_rate</key><value>1</value></param>
<param><key>decay_rate</key><value>1</value></param>
<param><key>reference</key><value>0.75</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>max_gain</key><value>0.0</value></param>
</block>
<block>
<key>analog_pwr_squelch_xx</key>
<param><key>id</key><value>squelch</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>squelch_slider</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>ramp</key><value>20</value></param>
<param><key>gate</key><value>True</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>250e3</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(com_freq_entry_1,20e6)</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0_0</value></param>
<param><key>stream_id</key><value>nav</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_2</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>5</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>vor_samp_rate</value></param>
<param><key>cutoff_freq</key><value>15e3</value></param>
<param><key>width</key><value>5e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0_0</value></param>
<param><key>stream_id</key><value>com</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>virtual_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc2_xx_0</source_block_id><sink_block_id>am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>am_demod_cf_0</source_block_id><sink_block_id>low_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>agc2_xx_0</source_block_id><sink_block_id>wxgui_fftsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multiply_xx_0_0</source_block_id><sink_block_id>add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>const_source_x_0_0</source_block_id><sink_block_id>add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>multiply_xx_0_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>add_xx_0_0</source_block_id><sink_block_id>float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>add_xx_0_0</source_block_id><sink_block_id>float_to_complex_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>float_to_complex_0_0</source_block_id><sink_block_id>multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0_0_0</source_block_id><sink_block_id>multiply_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>null_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_1</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_1_0</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_1</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>analog_agc2_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>goertzel_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_arg_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_3</source_block_id><sink_block_id>blocks_complex_to_arg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>low_pass_filter_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_agc2_xx_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0_0</source_block_id><sink_block_id>analog_agc2_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_am_demod_cf_0</source_block_id><sink_block_id>goertzel_fc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>goertzel_fc_0</source_block_id><sink_block_id>analog_agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0_0</source_block_id><sink_block_id>analog_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>low_pass_filter_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>low_pass_filter_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0_0</source_block_id><sink_block_id>null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_2</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>openavionics_audio_ptt_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openavionics_audio_ptt_0</source_block_id><sink_block_id>rational_resampler_xxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_2</source_block_id><sink_block_id>multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>squelch</source_block_id><sink_block_id>agc2_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>squelch</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>openavionics_joystick_interface_0</source_block_id><sink_block_id>openavionics_audio_ptt_0</sink_block_id><source_key>out</source_key><sink_key>in2</sink_key></connection>
<connection><source_block_id>virtual_source_0_0_0</source_block_id><sink_block_id>low_pass_filter_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
