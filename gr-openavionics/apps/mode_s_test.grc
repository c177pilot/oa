<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4000000</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>1090e6</value></param>
<param><key>gain0</key><value>19</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>openavionics_modes_block</key>
<param><key>id</key><value>openavionics_modes_block_0</value></param>
<param><key>rate</key><value>4000000.0</value></param>
<param><key>threshold</key><value>5.0</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>openavionics_modes_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
